# Keil uVision project Colsonic_apm.uvprojx, settings and files
target NAU88C22_USB_UAC_APM005 (6220000::V6.22::ARMCLANG)
  device: I94124 Nuvoton
  pack: Nuvoton.AudioSoCs_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0-0x7FFFF) CLOCK(196608000) CPUTYPE("Cortex-M4") FPU2
  output: NAU88C22_USB_UAC_APM005 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4,USB_ALITHM,DISABLE_WARNINGS,HAVE_CONFIG_H,CORE_M4,DSPC_CORTEX_M,ARM_MATH_CM4,__DEBUG__
  c include: ..\Library\StdDriver\inc;..\Library\CMSIS\Include;..\Library\Device\Nuvoton\I94100\Include;..\Library\Device\Nuvoton\I94100;..\Util;..\;..\App;..\Colsonic
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\I94124.sct
  link misc: --map --no_autoat --datacompressor=off --info=inline --entry Reset_Handler
  group CommonAudio
    ../../: audio_channel.h
  group CMSIS
    ./: startup_I94100.s
    ../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
  group User
    ../: main.c
  group Libraries
    ../Library/StdDriver/src/: clk.c dmic.c gpio.c i2c.c i2s.c pdma.c retarget.c spi.c sys.c timer.c uart.c usbd.c
  group Util
    ../Util/: audio_desc.c AudioClass.c init.c irq_handler.c misc.c pdma_handler.c Trim.c codec.c pdma_init.c
  group Colsonic
    ../Colsonic/: colsonic_def.c colsonic_para_set.c ColsonicData_Keil.s colsonic_apm_v0.0.5_20260213_0_0.lib
  group App
    ../App/: hwh_uart.c
