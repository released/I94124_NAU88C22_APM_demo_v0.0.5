# Keil uVision project Colsonic_16k.uvprojx, settings and files
target NAU88C22_I2S_I2C_APM005 (6220000::V6.22::ARMCLANG)
  device: I94124 Nuvoton
  pack: Nuvoton.NuVoice_ISD_DFP.1.0.20
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0-0x7FFFF) CLOCK(196608000) CPUTYPE("Cortex-M4") FPU2
  output: NAU88C22_I2S_I2C_APM005 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I94100\Include;..\..\..\..\Library\Device\Nuvoton\I94100;..\Util;..\;..\App;..\Colsonic
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\I94124.sct
  link misc: --map --no_autoat --datacompressor=off --info=inline --entry Reset_Handler
  group CommonAudio
    ../../: audio_channel.h
  group CMSIS
    ../../../../Library/Device/Nuvoton/I94100/Source/: system_I94100.c
    ./: startup_I94100.s
  group User
    ../: main.c
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c usbd.c uart.c dmic.c dpwm.c pdma.c gpio.c timer.c i2c.c i2s.c spi.c
  group Util
    ../Util/: init.c irq_handler.c misc.c pdma_handler.c Trim.c codec.c i2c_handler.c audio_desc.c AudioClass.c pdma_init.c
  group Colsonic
    ../Colsonic/: colsonic_apm_v0.0.5_20260213_0_0.lib colsonic_def.c colsonic_para_set.c ColsonicData_Keil.s
  group App
    ../App/: hwh_uart.c
